	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
ENTRY
	EXPORT Reset_Handler
Reset_Handler
	
	LDR R0,=HEXA
	LDR R0,[R0]

UPP CMP R0,#0
	BEQ EXIT
	
	MOV R1,#0
	
UP	CMP R0,#0XA
	BLO DOWN
	SUB R0,#0XA
	ADD R1,#1
	B UP
	
DOWN 
	LSL R0,R2
	ADD R3,R0
	ADD R2,#4
	MOV R0,R1
	B UPP
	
EXIT
	LDR R4,=BCD
	STR R3,[R4]
	
STOP
	B STOP

HEXA DCD 0XFF

	AREA mydata,DATA,READWRITE
	
BCD DCD 0

	END